Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Project Number
Time: 2020-03-24T09:12:07
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20160225_1515(x64) - Exporter 17.0.416.0 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Tue Mar 24 09:12:07 2020 * Host: LCOLTOI-RO-DE * Database: C:\Users\lcoltoi\AppData\Local\Temp\{AE4C5FB6-FA3E-483F-B8D3-066E6A59CF06}\ifc * Database version: 5507 * Database creation date: Tue Mar 24 09:12:05 2020 * Schema: IFC4 * Model: DataRepository.ifc * Model creation date: Tue Mar 24 09:12:06 2020 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Tue Mar 24 09:12:06 2020 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 23, 13, 199999; RefLongitude: -71, -14, -31, -199999; RefElevation: 0 mm
Dimensions - S4R_Use_nominal_diameter: yes
Identity Data - Design Option: Main Model
Other - Category: Project Information; Client Name: Client Name; Project Address: Enter address here; Project Issue Date: Project Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - Reference: Project Information; NumberOfStoreys: 1
Dimensions - S4R_Use_nominal_diameter: yes
Identity Data - Design Option: Main Model
Other - Category: Project Information; Client Name: Client Name; Project Address: Enter address here; Project Issue Date: Project Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuildingStorey, V00
LongName: V00; Elevation: 0 mm
Other - Category: Levels; Family Name: Level; Family: Level: Floor Level; Family and Type: Level: Floor Level; Type: Level: Floor Level; Type Id: Level: Floor Level
Identity Data - Type Name: Floor Level; Building Story: yes; Name: V00; Structural: no
Graphics - Color: 0; Line Pattern: Solid; Line Weight: 1; Symbol: GE_tag_level_floor_MEPcontent: standard; Symbol at End 1 Default: yes; Symbol at End 2 Default: yes
Constraints - Elevation: 0 mm; Elevation Base: Project Base Point
Dimensions - Computation Height: 0 mm

# IfcElectricDistributionBoard: U72 - IP31 168 modules 1134x560x120 opaque door FM 7R, E_Distribution Panel_MEPcontent_ABB_Compact Distribution U-UL_7 Rows_INT-EN:U72 - IP31 168 modules 1134x560x120 opaque door FM 7R:1314802
In: V00
Type - PredefinedType: DISTRIBUTIONBOARD; Material: Color RAL 9016
Type - Constraints - Default Elevation: 0 mm
Type - Dimensions - Depth (mm): 120 mm; Height (mm): 1134 mm; Width (mm): 560 mm
Type - Electrical - Class of Protection with Accessories: In combination with earthing set (accessory) we can achieve protection class 1; Degree of Protection: IP31; Protection Class: Double insulated; Rated Current In [A]: 125; Rated Operational Voltage Ue [V] AC: 400; Voltage: 400 V
Type - Electrical Engineering - Connection Voltage: 400 V; Phase: 3
Type - General - Area of Application: Internal use; Door Opening Angle [degrees]: 130; Door Type: Metal door; Grid Units (GU): 7; Interior Fitting: Expanded with distributor fields; Locking Type — Lock: Standard closure; Material of Enclosures: Sheet steel; Number of Rows: 7; Panel Width (PW): 2; RAL-Number: 9016; Space Units [SU]: 168
Type - Identity Data - Article Description: U72 Distribution Board FM 7R; Article Type: U72 - IP31 168 modules 1134x560x120 opaque door FM 7R; Base Family Version: 12.12; Category: EL_PANEL; Content Supplier URL: www.MEPcontent.com; Copyright: © Stabiplan International BV; Custom: no; Description: U72 Distribution Board FM 7R; EMCS Version: 4.0; ETIM Article Class: EC000214; Family Version: 12.12; GTIN: 4011617301141; Manufacturer: ABB; Manufacturer Art. No.: 2CPX030114R9999; Manufacturer URL: https://new.abb.com/products/2CPX030114R9999; MEPcontent Class: DISTRIBUTION_PANEL; Model: U72 - IP31 168 modules 1134x560x120 opaque door FM 7R; OmniClass Number: 23.80.30.11.17; OmniClass Title: Distribution Boards and Control Panels; Product Line: ABB; Revit Version: 2017; Type Name: U72 - IP31 168 modules 1134x560x120 opaque door FM 7R; URL: www.stabiplan.com; Watermarked By: www.stabiplan.com
Type - Materials and Finishes - Material: Color RAL 9016
Type - Other - Category: Electrical Equipment; Back Clearance: 60 mm; Bottom Clearance: 300 mm; Depth Safe: 120 mm; Door: yes; Double Door: no; Double Door Condition: 0 mm; Double Door Set: 1 mm; Family Name: E_Distribution Panel_MEPcontent_ABB_Compact Distribution U-UL_7 Rows_INT-EN; Front Clearance: 560 mm; Handle: yes; Height 1: 1144 mm; Height Safe: 1134 mm; Left Clearance: 560 mm; Length 1: 147 mm; Real Size Depth: 116.5 mm; Real Size Height: 1128 mm; Real Size Width: 553 mm; Right Clearance: 560 mm; Service Area Depth: 514.3 mm; Service Area Height: 1074 mm; Service Area Width 1: 257 mm; Service Area Width 2: 578 mm; Top Clearance: 300 mm; Width 1: 603.82 mm; Width Condition: 280 mm; Width Safe: 560 mm
Pset_ManufacturerTypeInformation - Manufacturer: ABB
Constraints - Offset: 0 mm
Dimensions - Area: 6.61386 m2; Volume: 0.101543 m3
Electrical - Circuiting - Electrical Data: Power - Unbalanced 400 V/3-0 VA
Electrical - Loads - Apparent Load Phase A: 0 W; Apparent Load Phase B: 0 W; Apparent Load Phase C: 0 W; Total Connected: 0 W; Total Demand Factor: 1; Total Estimated Demand: 0 W
Identity Data - Function Code: E6211; Mark: 2
Other - Family: E_Distribution Panel_MEPcontent_ABB_Compact Distribution U-UL_7 Rows_INT-EN: U72 - IP31 168 modules 1134x560x120 opaque door FM 7R; Family and Type: E_Distribution Panel_MEPcontent_ABB_Compact Distribution U-UL_7 Rows_INT-EN: U72 - IP31 168 modules 1134x560x120 opaque door FM 7R; Service Space Condition: no; Type: E_Distribution Panel_MEPcontent_ABB_Compact Distribution U-UL_7 Rows_INT-EN: U72 - IP31 168 modules 1134x560x120 opaque door FM 7R; Type Id: E_Distribution Panel_MEPcontent_ABB_Compact Distribution U-UL_7 Rows_INT-EN: U72 - IP31 168 modules 1134x560x120 opaque door FM 7R
Phasing - Phase Created: 3. New Construction
Visibility - Show Service Area: no
