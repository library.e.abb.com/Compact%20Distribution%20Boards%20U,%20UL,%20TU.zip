Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Project Number
Time: 2020-03-23T14:32:50
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20160225_1515(x64) - Exporter 17.0.416.0 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Mon Mar 23 14:32:50 2020 * Host: LCOLTOI-RO-DE * Database: C:\Users\lcoltoi\AppData\Local\Temp\{A10D9D3B-17D9-484C-9979-634AAE305699}\ifc * Database version: 5507 * Database creation date: Mon Mar 23 14:32:49 2020 * Schema: IFC4 * Model: DataRepository.ifc * Model creation date: Mon Mar 23 14:32:49 2020 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Mon Mar 23 14:32:49 2020 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 23, 13, 199999; RefLongitude: -71, -14, -31, -199999; RefElevation: 0 mm
Dimensions - S4R_Use_nominal_diameter: yes
Identity Data - Design Option: Main Model
Other - Category: Project Information; Client Name: Client Name; Project Address: Enter address here; Project Issue Date: Project Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - Reference: Project Information; NumberOfStoreys: 1
Dimensions - S4R_Use_nominal_diameter: yes
Identity Data - Design Option: Main Model
Other - Category: Project Information; Client Name: Client Name; Project Address: Enter address here; Project Issue Date: Project Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuildingStorey, V00
LongName: V00; Elevation: 0 mm
Other - Category: Levels; Family Name: Level; Family: Level: Floor Level; Family and Type: Level: Floor Level; Type: Level: Floor Level; Type Id: Level: Floor Level
Identity Data - Type Name: Floor Level; Building Story: yes; Name: V00; Structural: no
Graphics - Color: 0; Line Pattern: Solid; Line Weight: 1; Symbol: GE_tag_level_floor_MEPcontent: standard; Symbol at End 1 Default: yes; Symbol at End 2 Default: yes
Constraints - Elevation: 0 mm; Elevation Base: Project Base Point
Dimensions - Computation Height: 0 mm

# IfcElectricDistributionBoard: U52TE - IP31 120 modules 834x560x120 transparent door 5R, E_Distribution Panel_MEPcontent_ABB_Compact Distribution U-UL_5 Rows_INT-EN:U52TE - IP31 120 modules 834x560x120 transparent door 5R:1309614
In: V00
Type - PredefinedType: DISTRIBUTIONBOARD; Material: Color RAL 9016, Color RGB 224-227-233
Type - Constraints - Default Elevation: 0 mm
Type - Dimensions - Depth (mm): 120 mm; Height (mm): 834 mm; Width (mm): 560 mm
Type - Electrical - Class of Protection with Accessories: In combination with earthing set (accessory) we can achieve protection class 1; Degree of Protection: IP31; Protection Class: Double insulated; Rated Current In [A]: 125; Rated Operational Voltage Ue [V] AC: 400; Voltage: 400 V
Type - Electrical Engineering - Connection Voltage: 400 V; Phase: 3
Type - General - Area of Application: Internal use; Door Opening Angle [degrees]: 130; Door Type: Transparent door; Grid Units (GU): 5; Interior Fitting: Expanded with distributor fields; Locking Type — Lock: Standard closure; Material of Enclosures: Sheet steel; Number of Rows: 5; Panel Width (PW): 2; RAL-Number: 9016; Space Units [SU]: 120
Type - Identity Data - Article Description: U52TE Distribution Board 5R; Article Type: U52TE - IP31 120 modules 834x560x120 transparent door 5R; Base Family Version: 12.12; Category: EL_PANEL; Content Supplier URL: www.MEPcontent.com; Copyright: © Stabiplan International BV; Custom: no; Description: U52TE Distribution Board 5R; EMCS Version: 4.0; ETIM Article Class: EC000214; Family Version: 12.12; GTIN: 4011617715955; Manufacturer: ABB; Manufacturer Art. No.: 2CPX071595R9999; Manufacturer URL: https://new.abb.com/products/2CPX071595R9999; MEPcontent Class: DISTRIBUTION_PANEL; Model: U52TE - IP31 120 modules 834x560x120 transparent door 5R; OmniClass Number: 23.80.30.11.17; OmniClass Title: Distribution Boards and Control Panels; Product Line: ABB; Revit Version: 2017; Type Name: U52TE - IP31 120 modules 834x560x120 transparent door 5R; URL: www.stabiplan.com; Watermarked By: www.stabiplan.com
Type - Materials and Finishes - Material: Color RAL 9016
Type - Other - Category: Electrical Equipment; Back Clearance: 60 mm; Bottom Clearance: 300 mm; Depth Safe: 120 mm; Door: yes; Double Door: no; Double Door Condition: 14.6 mm; Double Door Set: 1 mm; Family Name: E_Distribution Panel_MEPcontent_ABB_Compact Distribution U-UL_5 Rows_INT-EN; First Left Transparency: 92.6 mm; First Right Transparency: 92.6 mm; Front Clearance: 560 mm; Handle: yes; Height 1: 841 mm; Height Safe: 834 mm; Left Clearance: 560 mm; Length 1: 150.5 mm; Real Size Depth: 120 mm; Real Size Height: 825 mm; Real Size Width: 553 mm; Right Clearance: 560 mm; Second Left Trnsparency: 92.6 mm; Second Right Transparency: 92.6 mm; Service Area Depth: 514.3 mm; Service Area Height: 774 mm; Service Area Width 1: 257 mm; Service Area Width 2: 578 mm; Top Clearance: 300 mm; Transparency Door Condition: 0 mm; Transparency Height: 755 mm; Transparent Door: yes; Width 1: 603.82 mm; Width Condition: 280 mm; Width Safe: 560 mm
Pset_ManufacturerTypeInformation - Manufacturer: ABB
Constraints - Offset: 0 mm
Dimensions - Area: 5.64778 m2; Volume: 0.0764258 m3
Electrical - Circuiting - Electrical Data: Power - Unbalanced 400 V/3-0 VA
Electrical - Loads - Apparent Load Phase A: 0 W; Apparent Load Phase B: 0 W; Apparent Load Phase C: 0 W; Total Connected: 0 W; Total Demand Factor: 1; Total Estimated Demand: 0 W
Identity Data - Design Option: Main Model; Function Code: E6211; Mark: 2
Other - Family: E_Distribution Panel_MEPcontent_ABB_Compact Distribution U-UL_5 Rows_INT-EN: U52TE - IP31 120 modules 834x560x120 transparent door 5R; Family and Type: E_Distribution Panel_MEPcontent_ABB_Compact Distribution U-UL_5 Rows_INT-EN: U52TE - IP31 120 modules 834x560x120 transparent door 5R; Service Space Condition: no; Type: E_Distribution Panel_MEPcontent_ABB_Compact Distribution U-UL_5 Rows_INT-EN: U52TE - IP31 120 modules 834x560x120 transparent door 5R; Type Id: E_Distribution Panel_MEPcontent_ABB_Compact Distribution U-UL_5 Rows_INT-EN: U52TE - IP31 120 modules 834x560x120 transparent door 5R
Phasing - Phase Created: 4. Plan over 10 years
Visibility - Show Service Area: no
