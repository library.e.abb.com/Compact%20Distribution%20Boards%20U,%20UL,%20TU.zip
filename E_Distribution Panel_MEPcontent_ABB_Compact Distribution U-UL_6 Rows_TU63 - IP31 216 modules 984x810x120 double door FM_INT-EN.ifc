Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Project Number
Time: 2020-03-24T08:45:31
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20160225_1515(x64) - Exporter 17.0.416.0 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Tue Mar 24 08:45:31 2020 * Host: LCOLTOI-RO-DE * Database: C:\Users\lcoltoi\AppData\Local\Temp\{64DF5E6A-5B88-4678-B811-9FC7C476FC0B}\ifc * Database version: 5507 * Database creation date: Tue Mar 24 08:45:31 2020 * Schema: IFC4 * Model: DataRepository.ifc * Model creation date: Tue Mar 24 08:45:31 2020 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Tue Mar 24 08:45:31 2020 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 23, 13, 199999; RefLongitude: -71, -14, -31, -199999; RefElevation: 0 mm
Dimensions - S4R_Use_nominal_diameter: yes
Other - Category: Project Information; Client Name: Client Name; Project Address: Enter address here; Project Issue Date: Project Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - Reference: Project Information; NumberOfStoreys: 1
Dimensions - S4R_Use_nominal_diameter: yes
Other - Category: Project Information; Client Name: Client Name; Project Address: Enter address here; Project Issue Date: Project Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuildingStorey, V00
LongName: V00; Elevation: 0 mm
Other - Category: Levels; Family Name: Level; Family: Level: Floor Level; Family and Type: Level: Floor Level; Type: Level: Floor Level; Type Id: Level: Floor Level
Identity Data - Type Name: Floor Level; Building Story: yes; Design Option: Main Model; Name: V00; Structural: no
Graphics - Color: 0; Line Pattern: Solid; Line Weight: 1; Symbol: GE_tag_level_floor_MEPcontent: standard; Symbol at End 1 Default: yes; Symbol at End 2 Default: yes
Constraints - Elevation: 0 mm; Elevation Base: Project Base Point
Dimensions - Computation Height: 0 mm

# IfcElectricDistributionBoard: TU63 - IP31 216 modules 984x810x120 double door FM, E_Distribution Panel_MEPcontent_ABB_Compact Distribution U-UL_6 Rows_INT-EN:TU63 - IP31 216 modules 984x810x120 double door FM:1305219
In: V00
Type - PredefinedType: DISTRIBUTIONBOARD; Material: Color RAL 9016
Type - Constraints - Default Elevation: 0 mm
Type - Dimensions - Depth (mm): 120 mm; Height (mm): 984 mm; Width (mm): 810 mm
Type - Electrical - Class of Protection with Accessories: In combination with earthing set (accessory) we can achieve protection class 1; Degree of Protection: IP31; Protection Class: Double insulated; Rated Current In [A]: 125; Rated Operational Voltage Ue [V] AC: 400; Voltage: 400 V
Type - Electrical Engineering - Connection Voltage: 400 V; Phase: 3
Type - General - Area of Application: Internal use; Door Opening Angle [degrees]: 130; Door Type: Metal door; Grid Units (GU): 6; Interior Fitting: Expanded with distributor fields; Locking Type — Lock: Standard closure; Material of Enclosures: Sheet steel; Number of Rows: 6; RAL-Number: 9016; Space Units [SU]: 216
Type - Identity Data - Article Description: TU63 Distribution Board FM; Article Type: TU63 - IP31 216 modules 984x810x120 double door FM; Base Family Version: 12.12; Category: EL_PANEL; Content Supplier URL: www.MEPcontent.com; Copyright: © Stabiplan International BV; Custom: no; Description: TU63 Distribution Board FM; EMCS Version: 4.0; ETIM Article Class: EC000214; Family Version: 12.12; GTIN: 4011617677178; Manufacturer: ABB; Manufacturer Art. No.: 2CPX067717R9999; Manufacturer URL: https://new.abb.com/products/2CPX067717R9999; MEPcontent Class: DISTRIBUTION_PANEL; Model: TU63 - IP31 216 modules 984x810x120 double door FM; OmniClass Number: 23.80.30.11.17; OmniClass Title: Distribution Boards and Control Panels; Product Line: ABB; Revit Version: 2017; Type Name: TU63 - IP31 216 modules 984x810x120 double door FM; URL: www.stabiplan.com; Watermarked By: www.stabiplan.com
Type - Materials and Finishes - Material: Color RAL 9016
Type - Other - Category: Electrical Equipment; Back Clearance: 60 mm; Bottom Clearance: 300 mm; Depth Safe: 120 mm; Door: yes; Double Door: yes; Double Door Condition: 264 mm; Double Door Set: 0 mm; Family Name: E_Distribution Panel_MEPcontent_ABB_Compact Distribution U-UL_6 Rows_INT-EN; First Left Transparency: 92.6 mm; First Right Transparency: 92.6 mm; Front Clearance: 560 mm; Handle: yes; Height 1: 991 mm; Height Safe: 984 mm; Left Clearance: 560 mm; Length 1: 147 mm; Real Size Depth: 116.5 mm; Real Size Height: 975 mm; Real Size Width: 803 mm; Right Clearance: 560 mm; Second Left Trnsparency: 92.6 mm; Second Right Transparency: 92.6 mm; Service Area Depth: 514.3 mm; Service Area Height: 924 mm; Service Area Width 1: 551.7 mm; Service Area Width 2: 703 mm; Top Clearance: 300 mm; Transparency Door Condition: 44 mm; Transparency Height: 1 mm; Transparent Door: no; Width 1: 853.82 mm; Width Condition: 405 mm; Width Safe: 810 mm
Pset_ManufacturerTypeInformation - Manufacturer: ABB
Constraints - Offset: 0 mm
Dimensions - Area: 6.99254 m2; Volume: 0.124401 m3
Electrical - Circuiting - Electrical Data: Power - Unbalanced 400 V/3-0 VA
Electrical - Loads - Apparent Load Phase A: 0 W; Apparent Load Phase B: 0 W; Apparent Load Phase C: 0 W; Total Connected: 0 W; Total Demand Factor: 1; Total Estimated Demand: 0 W
Identity Data - Design Option: Main Model; Function Code: E6211; Mark: 2
Other - Family: E_Distribution Panel_MEPcontent_ABB_Compact Distribution U-UL_6 Rows_INT-EN: TU63 - IP31 216 modules 984x810x120 double door FM; Family and Type: E_Distribution Panel_MEPcontent_ABB_Compact Distribution U-UL_6 Rows_INT-EN: TU63 - IP31 216 modules 984x810x120 double door FM; Service Space Condition: no; Type: E_Distribution Panel_MEPcontent_ABB_Compact Distribution U-UL_6 Rows_INT-EN: TU63 - IP31 216 modules 984x810x120 double door FM; Type Id: E_Distribution Panel_MEPcontent_ABB_Compact Distribution U-UL_6 Rows_INT-EN: TU63 - IP31 216 modules 984x810x120 double door FM
Phasing - Phase Created: 4. Plan over 10 years
Visibility - Show Service Area: no
